## platform/fpga/alsaqr/Kconfig
```kconfig
# SPDX-License-Identifier: BSD-2-Clause

config PLATFORM_ALSAQR_FPGA
	bool
	select FDT
	select SERIAL_UART8250
	select TIMER_MTIMER
	default y
```
